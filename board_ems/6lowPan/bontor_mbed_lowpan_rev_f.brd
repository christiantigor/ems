# Repository christiantigor/ems

## EAGLE design board_ems/6lowPan/bontor_mbed_lowpan_rev_f.brd

Parts:
ADE-C5: 10uF; 153CLV-0605
ADE-C7, ADE-C8, ADE-C9, ADE-C10: 33nF; 0603-CAP
ADE-C11, ADE-C12, ADE-C13, ADE-C14, ADE-C15, ADE-C16: 33nF; 0402-CAP
ADE-R1, ADE-R2, ADE-R3: 81K; 0603-RES
ADE-R4, ADE-R5, ADE-R6, ADE-R7: 1K; 0603-RES
ADE-R8, ADE-R11, ADE-R14: 33R; 0402-RES
ADE-R9, ADE-R10, ADE-R12, ADE-R13, ADE-R15, ADE-R16: 1K; 0402-RES
ADE-XTAL: 10MHz; HC49US
ANT1, ANT2: U.FL
B1: 2450BM15A0002; 2450BM
BAT1: BATTERY12MM; BATTCON_12MM
C10, C11, C71: 0.1uF; C0603@1
C20, C24, C25, C26, C31, C33, C35, C50, C51, C53, C56, C70: 100nF; C0603
C21, C22: 4.3pF; C0603
C23: 1uF; C0603
C27, C40, C41, C43, C46: 100nF; C0402
C28, C52: 4.7uF; C0603
C30, C55: 10nF; C0603
C32, C34: 6.8nF; C0603
C36: 22nF; C0603
C37: 10uF/16V; 153CLV-0605
C44, C45: 27p; C0201
C54, C57: 18pF; C0603
C72: 10uF; C0805K
C73, C74: 22pF; C0603
C80: 100nF; C0603K
C81: 22pF; C0603K
C96, C97: 100uF; 153CLV-0605
DCDC: DCDCMODULE_360; DCDCMODULE-360
DHT-R1: 10k; R0603
ESP: ESP; WI12
ESP-C1: 100nF; C0603
ESP-GPIO0: PINHD-1X3; 1X03
ESP_EXT: PINHD4
ETH-R4, ETH-R5: 330; R0603
ETHERNET: RJ45J0026D21BNL; RJ45_PULSEJACK
HLK-PM01: HLK-PM01
IC1: SIM900; SIM900_SMT
IC2, IC3, IC5: 74HC595D; SO16
IC4: ADE7758RW; SOIC24
JP1: PINHD-2X4; 2X04
JRX: 0; R0201
JTX: 0; R0201
L1, L2: 150Mhz; FB805
L3: BLM15HB121SN1; 0402
LCD14: LCD_2.4; LCD_TOUCH_2-4
LCD-R1: 680R; 0603-RES
LCD_C1: 100nF; C0603
LED1, LED2: LED0805_NOOUTLINE; CHIPLED_0805_NOOUTLINE
MQ2-R1: 10k; R0603
OK1, OK2: ILD205; SOIC08
PWR: R-EU_R0402; R0402
R10: 10R; 0603-RES
R30, R32, R34, R35: 49R9; R0603
R31: 12K4; R0805
R33: 10R; R0603
R50, R51, R54: 10k; R0603
R52, R53: 10k; RN8P-4R-CRA06S
R56: 1M; R0603
R90, R96: 10K; R0603
R91, R95: 1K; R0603
R92, R94: 680R; R0603
R93: 120R; R0603
RBIAS: 56k; 0402-RES
RJ-1, RJ-2, RJ-3: RJ11-4P-V
RT1, RT2, RT3: R-EU_0309/V; 0309V
RTO1, RTO2, RTO3: R-US_0309_12; 0309_12
R_CH1, R_CH2, R_CH3, R_CH4: 270; 0603-RES
R_VREG: 10K; 0402-RES
S1: TAC_SWITCHPTH; TACTILE-PTH
SENSOR-MQ2: METHANE_SENSOR; MQ-3
SIM900-C3: 4u7; C0603
SIM900-C4: 100nF; C0603
SIM900-C5: 22pF; C0603
SIM900-R1, SIM900-R2, SIM900-R3: 22R; R0603
SIMHOLDER: SIM_HOLDER; SIMHOLDER-PUSHPUSH
SR_OUT1, SR_OUT2: PINHD-2X5; 2X05
STM-C13: 100nF; C0603
STM-SWD: PINHD4
STM-USART: PINHD4
STMF401: STM32F103RBT6; QFP50P1200X1200X160-64N
SYS-C1, SYS-C2: 0.1uF; C0603@1
SYS-R1: 10R; 0603-RES
T1, T2, T3: MMBT2222ALT1-NPN-SOT23-BEC; SOT23-BEC
TERM_BLOCK: TERMINAL_BLOCK_TW; TERMINAL-TWO-WAY
TV16-1, TV16-2, TV16-3: TRANSFORMER; TV16
U2: W5500
U$4: CC2520; QFN50P500X500X100-29N
U$17: DHT11
USB_IN: USB_MICROB; USB-B-MICRO-SMD_V03
W5500-C13: 10uF/16V; 153CLV-0605
X1: NX2520SA
XTAL1: 32.768kHz; TC26H
XTAL2: 25MHz; QS

Connections:
+5V: ADE-C5.+, C70.1, DCDC.VIN, HLK-PM01.VOUT, IC4.3 (DVDD), R_CH1.1, R_CH2.1, R_CH3.1, R_CH4.1, SENSOR-MQ2.A1, SENSOR-MQ2.A2, SENSOR-MQ2.HA, SR_OUT1.1, SR_OUT2.1, SYS-C1.1, SYS-R1.1, USB_IN.VBUS1 (VCC)
ACTLED: ETH-R4.1, U2.27 (ACTLED)
ADE_APCF: IC4.1 (APCF), STMF401.62 (PB9)
ADE_IRQ: IC4.18 (IRQ), STMF401.59 (PB7)
ADE_MISO: IC4.24 (DO), STMF401.56 (PB4)
ADE_MOSI: IC4.22 (DI), STMF401.58 (PB6)
ADE_SCK: IC4.23 (SCK), STMF401.57 (PB5)
ADE_VARCF: IC4.17 (VARCF), STMF401.61 (PB8)
AGND: ADE-C7.2, ADE-C8.2, ADE-C9.2, ADE-C10.2, ADE-C11.2, ADE-C12.2, ADE-C13.2, ADE-C14.2, ADE-C15.2, ADE-C16.2, ADE-R4.1, ADE-R5.1, ADE-R6.1, C11.2, C25.2, C71.2, C72.2, ETHERNET.4 (GND1), ETHERNET.5 (GND2), IC4.11 (AGND), L1.1, STMF401.12 (VSSA), SYS-C2.2, U$4.29 (AGND)
AVDD: IC4.4 (AVDD), SYS-C2.1, SYS-R1.2
CC_GPIO0: STMF401.5 (PH0_-OSC_IN), U$4.10 (GPIO0)
CC_GPIO1: STMF401.40 (PC9), U$4.9 (GPIO1)
CC_GPIO2: STMF401.39 (PC8), U$4.7 (GPIO2)
CC_GPIO3: STMF401.38 (PC7), U$4.6 (GPIO3)
CC_GPIO4: STMF401.15 (PA1), U$4.5 (GPIO4)
CC_GPIO5: STMF401.14 (PA0-WKUP1), U$4.4 (GPIO5)
CC_MISO: STMF401.52 (PC11), U$4.1 (SO)
CC_MOSI: STMF401.2 (PC13-RTC_AF1-WKUP2), U$4.2 (SI)
CC_RESET: U$4.25 (RESET)
CC_SCK: STMF401.53 (PC12), U$4.28 (SCLK)
CH1_A: JP1.1, OK2.8 (COL)
CH1_B: JP1.2, OK2.7 (EMIT)
CH1_IN: IC5.15 (QA), OK2.2 (C)
CH2_A: JP1.3, OK2.6 (COL)
CH2_B: JP1.4, OK2.5 (EMIT)
CH2_IN: IC5.1 (QB), OK2.4 (C)
CH3_A: JP1.5, OK1.8 (COL)
CH3_B: JP1.6, OK1.7 (EMIT)
CH3_IN: IC5.2 (QC), OK1.2 (C)
CH4_A: JP1.7, OK1.6 (COL)
CH4_B: JP1.8, OK1.5 (EMIT)
CH4_IN: IC5.3 (QD), OK1.4 (C)
DC_VOUT: DCDC.VOUT, PWR.2
DGND: ADE-C5.-, ANT1.P$1 (GND), ANT1.P$2 (GND), ANT2.P$1 (GND), ANT2.P$2 (GND), B1.2 (GND), B1.5 (GND), B1.6 (GND), BAT1.GND (-), C10.2, C20.2, C21.1, C22.1, C23.1, C24.2, C26.2, C27.2, C28.2, C30.1, C31.2, C33.2, C35.2, C36.1, C37.-, C40.2, C41.2, C43.2, C44.2, C45.2, C46.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C70.2, C73.2, C74.2, C80.1, C81.1, C96.-, C97.-, DCDC.GND$1 (GNDI), DCDC.GND$2 (GNDO), ESP.GND, ESP.GPIO15, ESP-C1.2, ESP-GPIO0.3, HLK-PM01.GND, IC1.P$17 (GND), IC1.P$18 (GND), IC1.P$29 (GND), IC1.P$39 (GND), IC1.P$45 (GND), IC1.P$46 (GND), IC1.P$53 (GND), IC1.P$54 (GND), IC1.P$58 (GND), IC1.P$59 (GND), IC1.P$61 (GND), IC1.P$62 (GND), IC1.P$63 (GND), IC1.P$64 (GND), IC1.P$65 (GND), IC2.8 (GND), IC2.13 (G), IC3.8 (GND), IC3.13 (G), IC4.2 (DGND), IC4.21 (CS), IC5.8 (GND), IC5.13 (G), L1.2, LCD14.LCD_GND, LCD14.T_CS, LCD_C1.2, MQ2-R1.1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
DHT_DATA: DHT-R1.2, STMF401.54 (PD2), U$17.DATA
ESP_GPIO0: ESP.GPIO00 (GPIO0), ESP-GPIO0.2
ESP_RX: ESP.RXD, ESP_EXT.3, JRX.1
ESP_TX: ESP.TXD, ESP_EXT.4, JTX.1
ETH_CS: R54.1, STMF401.33 (PB12), U2.32 (SCS_N)
ETH_MISO: STMF401.35 (PB14), U2.34 (MISO)
ETH_MOSI: STMF401.36 (PB15), U2.35 (MOSI)
ETH_RSTN: R51.2, STMF401.37 (PC6), U2.37 (RST_N)
ETH_SCK: STMF401.34 (PB13), U2.33 (SCLK)
GPIO11: IC1.P$67 (GPIO11)
GPIO12: IC1.P$68 (GPIO12)
IBN: ADE-R11.1, ADE-R13.1, RJ-2.P$1, RJ-2.P$2
ICN: ADE-R14.1, ADE-R16.1, RJ-1.P$1, RJ-1.P$2
LCD_CS: LCD14.LCD_CS, STMF401.20 (PA4)
LCD_D/C: LCD14.LCD_D/C, STMF401.24 (PC4)
LCD_LED: LCD14.LED (LCD_LED), LCD-R1.1
LCD_MISO: LCD14.LCD_MISO, LCD14.SD_MISO, STMF401.22 (PA6)
LCD_MOSI: LCD14.LCD_MOSI, LCD14.SD_MOSI, STMF401.23 (PA7)
LCD_RESET: LCD14.LCD_RESET, STMF401.25 (PC5)
LCD_SCK: LCD14.LCD_SCK, LCD14.SD_SCK, STMF401.21 (PA5)
LINKLED: ETH-R5.1, U2.25 (LINKLED)
MQ2_DATA: MQ2-R1.2, SENSOR-MQ2.B1, SENSOR-MQ2.B2, STMF401.6 (PH1-_OSC_OUT)
N: HLK-PM01.AC$2 (AC_IN$2), TERM_BLOCK.PIN$4, TV16-1.IB, TV16-2.IB, TV16-3.IB
unnamed: C22.2, STMF401.3 (PC14-OSC32_IN), XTAL1.2
unnamed: C21.2, STMF401.4 (PC15-OSC32_OUT), XTAL1.1
unnamed: IC1.P$31 (SIM_DATA), SIM900-R3.1
unnamed: OK2.1 (A), R_CH1.2
unnamed: OK2.3 (A), R_CH2.2
unnamed: OK1.1 (A), R_CH3.2
unnamed: IC1.P$32 (SIM_CLK), SIM900-R2.1
unnamed: R_VREG.1, U$4.26 (VREG-EN)
unnamed: ADE-C9.1, ADE-R3.2, ADE-R6.2, IC4.14 (VCP)
unnamed: ETH-R4.2, ETHERNET.10 (LED1_K)
unnamed: ETH-R5.2, ETHERNET.11 (LED2_K)
unnamed: IC1.P$33 (SIM_RST), SIM900-R1.1
unnamed: IC1.P$26 (VRTC), SIM900-C3.1
unnamed: ANT1.P$3 (SIGNAL), IC1.P$60 (RF_ANT)
unnamed: LED1.A, R94.1
unnamed: LED1.C, T1.C
unnamed: R95.1, R96.1, T1.B
unnamed: LED2.A, R92.1
unnamed: LED2.C, T2.C
unnamed: R90.1, R91.1, T2.B
unnamed: C32.1, ETHERNET.7 (RX+)
unnamed: C36.2, ETHERNET.3 (TCT), R33.1
unnamed: ADE-C15.1, ADE-R15.2, IC4.9 (IP)
unnamed: ADE-R11.2, ADE-R12.1, RJ-2.P$3, RJ-2.P$4
unnamed: C34.1, ETHERNET.8 (RX-)
unnamed: ADE-C11.1, ADE-R9.2, IC4.5 (IP)
unnamed: ADE-C12.1, ADE-R10.2, IC4.6 (IN)
unnamed: C30.2, ETHERNET.6 (RCT), R30.1, R32.2
unnamed: ADE-C14.1, ADE-R13.2, IC4.8 (IN)
unnamed: ADE-C13.1, ADE-R12.2, IC4.7 (IP)
unnamed: C71.1, C72.1, IC4.12 (REF)
unnamed: ADE-XTAL.1, C73.1, IC4.19 (CLKIN)
unnamed: ADE-XTAL.2, C74.1, IC4.20 (CLKOUT)
unnamed: ADE-C10.1, ADE-R7.2, IC4.13 (VN)
unnamed: ADE-R2.1, RTO2.2, TV16-2.OA
unnamed: ADE-C8.1, ADE-R2.2, ADE-R5.2, IC4.15 (VBP)
unnamed: C52.1, U2.20 (TOCAP)
unnamed: ADE-R8.2, ADE-R9.1, RJ-3.P$3, RJ-3.P$4
unnamed: ADE-C16.1, ADE-R16.2, IC4.10 (IN)
unnamed: C55.1, U2.22 (1V2O)
unnamed: R50.2, U2.23 (RSVD)
unnamed: C40.1, U$4.27 (DCOUPL)
unnamed: R93.2, T3.B
unnamed: OK1.3 (A), R_CH4.2
unnamed: ADE-R8.1, ADE-R10.1, RJ-3.P$1, RJ-3.P$2
unnamed: ADE-R14.2, ADE-R15.1, RJ-1.P$3, RJ-1.P$4
unnamed: C57.1, R56.2, U2.31 (XO), XTAL2.2
unnamed: R31.2, U2.10 (EXRES1)
unnamed: ADE-C7.1, ADE-R1.2, ADE-R4.2, IC4.16 (VAP)
unnamed: ADE-R1.1, RTO1.2, TV16-1.OA
unnamed: ADE-R7.1, RTO1.1, RTO2.1, RTO3.1, TV16-1.OB, TV16-2.OB, TV16-3.OB
unnamed: R52.4 (1), U2.38 (RSVD)
unnamed: R52.3 (1), U2.39 (RSVD)
unnamed: R52.2 (1), U2.40 (RSVD)
unnamed: R52.1, U2.41 (RSVD)
unnamed: R53.8 (2), U2.42 (RSVD)
unnamed: R53.7 (2), U2.43 (PMODE2)
unnamed: R53.6 (2), U2.44 (PMODE1)
unnamed: R53.5 (2), U2.45 (PMODE0)
unnamed: ADE-R3.1, RTO3.2, TV16-3.OA
unnamed: C54.1, R56.1, U2.30 (XI/CLKIN), XTAL2.1
unnamed: C96.+, C97.+, IC1.P$55 (VBAT1), IC1.P$56 (VBAT2), IC1.P$57 (VBAT3), L2.1
unnamed: C44.1, U$4.13 (XOSC32M-Q1), X1.1
unnamed: C45.1, U$4.12 (XOSC32M-Q2), X1.3 (2)
unnamed: JRX.2, STMF401.16 (PA2)
unnamed: JTX.2, STMF401.17 (PA3)
unnamed: RT3.2, TV16-3.IA
unnamed: RT2.2, TV16-2.IA
unnamed: RT1.2, TV16-1.IA
unnamed: RBIAS.1, U$4.23 (RBIAS)
unnamed: C28.1, STMF401.30 (PB11)
unnamed: B1.4 (BAL_P), U$4.17 (RF-P)
unnamed: B1.3 (BAL_N), U$4.19 (RF-N)
unnamed: ANT2.P$3 (SIGNAL), B1.1 (ANT)
Q1: IC2.15 (QA), SR_OUT1.3
Q2: IC2.1 (QB), SR_OUT1.4
Q3: IC2.2 (QC), SR_OUT1.5
Q4: IC2.3 (QD), SR_OUT1.6
Q5: IC2.4 (QE), SR_OUT1.7
Q6: IC2.5 (QF), SR_OUT1.8
Q7: IC2.6 (QG), SR_OUT1.9
Q8: IC2.7 (QH), SR_OUT1.10
Q9: IC3.15 (QA), SR_OUT2.3
Q10: IC3.1 (QB), SR_OUT2.4
Q11: IC3.2 (QC), SR_OUT2.5
Q12: IC3.3 (QD), SR_OUT2.6
Q13: IC3.4 (QE), SR_OUT2.7
Q14: IC3.5 (QF), SR_OUT2.8
Q15: IC3.6 (QG), SR_OUT2.9
Q16: IC3.7 (QH), SR_OUT2.10
QS: IC2.9 (QH*), IC3.14 (SER)
QS2: IC3.9 (QH*), IC5.14 (SER)
R: HLK-PM01.AC$1 (AC_IN$1), RT1.1, TERM_BLOCK.PIN$1
RXN: C34.2, R32.1, U2.5 (RXN)
RXP: C32.2, R30.2, U2.6 (RXP)
S: RT2.1, TERM_BLOCK.PIN$2
SD_CS: LCD14.SD_CS, STMF401.55 (PB3)
SERIAL_RX: STM-USART.3, STMF401.43 (PA10)
SERIAL_TX: STM-USART.2, STMF401.42 (PA9)
SIM900_PWRKEY: IC1.P$1 (PWRKEY), T3.C
SIM_NETLIGHT: IC1.P$52 (NETLIGHT), R91.2
SIM_PWRKEY: R93.1, STMF401.41 (PA8)
SIM_RX: IC1.P$10 (RXD), STMF401.51 (PC10)
SIM_STATUS: IC1.P$66 (STATUS), R95.2
SIM_TX: IC1.P$9 (TXD), STMF401.50 (PA15)
SR_DS: IC2.14 (SER), STMF401.8 (PC0)
SR_RST: IC2.10 (SCL), IC3.10 (SCL), IC5.10 (SCL), STMF401.11 (PC3)
SR_SHCP: IC2.11 (SCK), IC3.11 (SCK), IC5.11 (SCK), STMF401.10 (PC2)
SR_STCP: IC2.12 (RCK), IC3.12 (RCK), IC5.12 (RCK), STMF401.9 (PC1)
SWD_NRST: C20.1, S1.1, S1.2, STMF401.7 (NRST)
SWD_TCK: STM-SWD.2, STMF401.49 (PA14)
SWD_TMS: STM-SWD.4, STMF401.46 (PA13)
T: RT3.1, TERM_BLOCK.PIN$3
TXN: ETHERNET.2 (TX-), R34.1, U2.1 (TXN)
TXP: ETHERNET.1 (TX+), R35.1, U2.2 (TXP)
T_CLK: LCD14.T_CLK, STMF401.27 (PB1)
T_DIN: LCD14.T_DIN, STMF401.29 (PB10)
T_DO: LCD14.T_DO, STMF401.26 (PB0)
T_IRQ: LCD14.T_IRQ, STMF401.28 (PB2)
USB_DM: STMF401.44 (PA11), USB_IN.D-1 (D-)
USB_DP: STMF401.45 (PA12), USB_IN.D+1 (D+)
USIM_CLK: SIM900-R2.2, SIMHOLDER.SIM_CLK
USIM_DATA: SIM900-R3.2, SIMHOLDER.SIM_IO
USIM_RESET: SIM900-R1.2, SIMHOLDER.SIM_RST
USIM_VCC: C80.2, C81.2, IC1.P$30 (SIM_VDD), SIM900-C4.1, SIM900-C5.1, SIMHOLDER.SIM_VDD
VBAT: BAT1.PWR@1 (+), STMF401.1 (VLCD)
VCC: C11.1, C25.1, C31.1, C33.1, C35.1, C37.+, C50.1, C51.1, C53.1, L3.2, R10.2, R33.2, R34.2, R35.2, STMF401.13 (VDDA), U2.4 (AVDD), U2.8 (AVDD), U2.11 (AVDD), U2.15 (AVDD), U2.17 (AVDD), U2.21 (AVDD)
VDD: C10.1, C23.2, C24.1, C26.1, C27.1, C41.1, C43.1, C46.1, C56.1, DHT-R1.1, ESP_EXT.1, ETHERNET.9 (LED1_A), ETHERNET.12 (LED2_A), IC2.16 (VCC), IC3.16 (VCC), IC5.16 (VCC), L2.2, L3.1, LCD14.LCD_VCC, LCD-R1.2, LCD_C1.1, PWR.1, R10.1, R51.1, R53.2 (1), R53.3 (1), R53.4 (1), R54.2, R92.2, R94.2, R_VREG.2, STM-C13.1, STM-SWD.1, STM-USART.1, STMF401.19 (VDD_4), STMF401.32 (VDD_1), STMF401.48 (VDD_2), STMF401.64 (VDD_3), U2.28 (VDD), U$4.8 (DVDD), U$4.11 (AVDD), U$4.14 (AVDD), U$4.16 (AVDD), U$4.20 (AVDD), U$4.22 (AVDD), U$4.24 (AVDD-GUARD), U$17.VCC, W5500-C13.+
VESP: ESP.CH_PD, ESP.GPIO02 (GPIO2), ESP.REST, ESP.VCC, ESP-C1.1, ESP-GPIO0.1, ESP_EXT.2

Board: 2 copper layers, 96.3 x 105.3 mm, 172 parts (61 on the bottom side), 183 nets.

## EAGLE design board_ems/esp_converter/esp_converter.brd

Parts:
JP1: PINHD-1X3; 1X03
U$2, U$3: 1X10
U$4: PINHD4
U$5: PINHD2

Connections:
3V3: JP1.1, U$2.1, U$2.3, U$2.8, U$3.6, U$3.9, U$3.10, U$4.4, U$5.2
GND: JP1.3, U$3.7, U$3.8, U$4.1, U$5.1
GPIO0: JP1.2, U$3.5
RXD: U$3.2, U$4.3
TXD: U$3.1, U$4.2

Board: 2 copper layers, 30.5 x 30.5 mm, 5 parts (0 on the bottom side), 5 nets.

Notices in the files:
parts and their libraries:
SparkFun-Passives: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
